# IAR project project.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8L152M8 STM8L152M8
  General.GenCodeModel: 1
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: REGION_CN470; ACTIVE_REGION=LORAMAC_REGION_CN470; CONFIG_RAM_OPT; CONFIG_UART_DEBUG=1; CONFIG_UART_CMD=0
  ICCSTM8.CCIncludePath2: ..\inc; ..\..\..\Libraries\STM8L15x_StdPeriph_Driver\inc; ..\..\..\LoRaMac-node\src\boards; ..\..\..\LoRaMac-node\src\boards\ASR6505; ..\..\..\LoRaMac-node\src\radio; ..\..\..\LoRaMac-node\src\radio\sx126x; ..\..\..\LoRaMac-node\src\system; ..\..\..\LoRaMac-node\src\system\crypto; ..\..\..\LoRaMac-node\src\mac; ..\..\..\LoRaMac-node\src\mac\region; ..\..\..\LoRaMac-node\src\apps\LoRaMac\classA\ASR6505
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: project.hex
  ILINK.IlinkOutputFile: project.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  General.GenCodeModel: 0
  ICCSTM8.CCDefines: NDEBUG
  group LoraNode/mac
    ../../../LoRaMac-node/src/mac/: LoRaMac.c LoRaMac.h LoRaMacClassB.c LoRaMacConfirmQueue.c LoRaMacCrypto.c LoRaMacCrypto.h
    ../../../LoRaMac-node/src/mac/region/: Region.c Region.h RegionCN470.c RegionCN470.h RegionCommon.c RegionCommon.h
  group LoraNode/mac/board
    ../../../LoRaMac-node/src/boards/: board.h delay-board.h gpio-board.h pinName-board.h rtc-board.h spi-board.h sx126x-board.h uart-board.h utilities.h
  group LoraNode/mac/board/ASR6505
    ../../../LoRaMac-node/src/boards/ASR6505/: board-config.h board.c delay-board.c gpio-board.c rtc-board.c spi-board.c sx1262-board.c uart-board.c
  group LoraNode/radio
    ../../../LoRaMac-node/src/radio/sx126x/: radio.c sx126x.c sx126x.h
    ../../../LoRaMac-node/src/radio/: radio.h
  group LoraNode/system
    ../../../LoRaMac-node/src/system/: delay.c delay.h gpio.c gpio.h spi.h timer.c timer.h
    ../../../LoRaMac-node/src/boards/mcu/: utilities.c
  group LoraNode/system/crypto
    ../../../LoRaMac-node/src/system/crypto/: aes.c aes.h cmac.c cmac.h
  group STM8L15x_StdPeriph_Driver/inc
    ../../../Libraries/STM8L15x_StdPeriph_Driver/inc/: stm8l15x.h stm8l15x_adc.h stm8l15x_aes.h stm8l15x_beep.h stm8l15x_clk.h stm8l15x_comp.h stm8l15x_dac.h stm8l15x_dma.h stm8l15x_exti.h stm8l15x_flash.h stm8l15x_gpio.h stm8l15x_i2c.h stm8l15x_irtim.h stm8l15x_itc.h stm8l15x_iwdg.h stm8l15x_lcd.h stm8l15x_pwr.h stm8l15x_rst.h stm8l15x_rtc.h stm8l15x_spi.h stm8l15x_syscfg.h stm8l15x_tim1.h stm8l15x_tim2.h stm8l15x_tim3.h stm8l15x_tim4.h stm8l15x_tim5.h stm8l15x_usart.h stm8l15x_wfe.h stm8l15x_wwdg.h
  group STM8L15x_StdPeriph_Driver/src
    ../../../Libraries/STM8L15x_StdPeriph_Driver/src/: stm8l15x_aes.c stm8l15x_clk.c stm8l15x_dma.c stm8l15x_exti.c stm8l15x_flash.c stm8l15x_gpio.c stm8l15x_i2c.c stm8l15x_iwdg.c stm8l15x_pwr.c stm8l15x_rtc.c stm8l15x_spi.c stm8l15x_syscfg.c stm8l15x_tim1.c stm8l15x_tim2.c stm8l15x_tim3.c stm8l15x_tim4.c stm8l15x_tim5.c stm8l15x_usart.c stm8l15x_wwdg.c
  group User/inc
    ../../../LoRaMac-node/src/apps/LoRaMac/classA/ASR6505/: Commissioning.h
    ../inc/: stm8l15x_conf.h stm8l15x_it.h
  group User/src
    ../../../LoRaMac-node/src/apps/LoRaMac/classA/ASR6505/: ATcmd.c ATcmd.h main.c readme.c
    ../src/: stm8_interrupt_vector.c stm8l15x_it.c
